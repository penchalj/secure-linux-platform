FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://secure-linux-kmeta;type=kmeta;name=secure-linux-kmeta;destsuffix=secure-linux-kmeta"
